## board/ncx1_mk1/ncx1_mk1sd_uboot_defconfig
```kconfig
CONFIG_NCX1_MK1=y
CONFIG_RAM_256MB=y
CONFIG_SDCARD=y
CONFIG_DEBUG=y
CONFIG_THUMB=y
```
